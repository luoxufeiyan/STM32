# Keil uVision project iSO-STM32.uvprojx, settings and files
target enc28j60+lwip (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\Libraries\FWlib\src;..\..\User;..\..\User\app;..\..\User\enc28j60;..\..\User\led;..\..\User\systick;..\..\User\usart1;..\..\LWIP;..\..\LWIP\ARCH;..\..\LWIP\lwip-1.3.2\src\include;..\..\LWIP\lwip-1.3.2\src\include\ipv4;..\..\LWIP\lwip-1.3.2\src\include\netif;..\..\LWIP\lwip-1.3.2\src\include\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/led/: bsp_led.c
    ../../User/systick/: bsp_SysTick.c
    ../../User/usart1/: bsp_usart1.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group enc28j60
    ../../User/enc28j60/: ENC28J60.C SPI.C
  group app
    ../../User/app/: cmd.c httpd.c netconfig.c
  group lwip-api
    ../../LWIP/lwip-1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-core
    ../../LWIP/lwip-1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwip-core-ipv4
    ../../LWIP/lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-core-snmp
    ../../LWIP/lwip-1.3.2/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group lwip-netif
    ../../LWIP/lwip-1.3.2/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
software components: CMSIS:CORE 4.1.0
